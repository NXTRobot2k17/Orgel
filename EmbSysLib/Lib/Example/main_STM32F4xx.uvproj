# Keil uVision project main_STM32F4xx.uvproj, settings and files
target Target (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: main +hex
  c flags: Optim=1 OneElfS=1
  c define: _KEIL, STM32F407xx, _HSE_CLK=8000, _HSE_BYPASS_ON
  c include: .\Src;..\Src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ../Src/Hardware/MCU/STM32F4xx/Sys/Keil/: startup_stm32f4xx.s RTOScontext.s
    ../Src/: lib.cpp
    ./: main.cpp
    ../Src/Module/: USB.cpp RTOS.cpp HTTP.cpp Download.cpp ISC.cpp
