# Keil uVision project main_LPC11Uxx.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC11U35/401 NXP
  cpu: IRAM(0x10000000-0x10001FFF) IRAM2(0x20004000-0x200047FF) IROM(0-0xFFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: main +hex
  c flags: Optim=1 OneElfS=1
  c define: __ARM_LPC11U35__ DISP_TERM, _KEIL
  c include: .\src;..\Src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20004000 size 0x800
  group Source Group 1
    ../src/: lib.cpp
    ./: main.cpp
    ../Src/Module/: Command.cpp RTOS.cpp USB.cpp HTTP.cpp
    ../Src/Hardware/MCU/LPC11Uxx/Sys/Keil/: startup_LPC11Uxx_keil.s RTOS_Asm_keil.s
