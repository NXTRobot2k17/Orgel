# Keil uVision project main_LPC17xx.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC1758 NXP
  pack: Keil.LPC1700_DFP.2.3.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: _KEIL, LPC1758, xTERMINAL
  c include: .\src;..\EmbSysLib\Lib\Src
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ../EmbSysLib/Lib/Src/Hardware/MCU/LPC17xx/Sys/Keil/: startup_LPC17xx.s RTOS_Asm.s
    ../EmbSysLib/Lib/Src/: lib.cpp
    ../EmbSysLib/Lib/Src/Module/: RTOS.cpp
    ./Src/: main.cpp Analog.cpp Analog.h AnalogADC_IO.h AnalogIn.cpp AnalogIn.h AnalogInADC.cpp AnalogInADC.h AnalogOut.cpp AnalogOut.h AnalogOutDAC.cpp AnalogOutDAC.h PWM.cpp PWM.h
software components: CMSIS:CORE 5.0.1
